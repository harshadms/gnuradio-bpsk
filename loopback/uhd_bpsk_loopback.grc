options:
  parameters:
    author: harshad
    generate_options: no_gui
    id: uhd_bpsk_loopback
    output_language: python
    title: BPSK Loopback
  states: {}

blocks:
- name: Const_HDR
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: amp
  id: variable
  parameters:
    value: '21.5'
  states: {}
- name: dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec_hdr
  id: variable_repetition_decoder_def
  parameters:
    framebits: hdr_format.header_nbits()
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.6'
  states: {}
- name: enc
  id: variable_cc_encoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: enc_hdr
  id: variable_repetition_encoder_def
  parameters:
    framebits: '128'
    ndim: '0'
    rep: rep
  states: {}
- name: freq
  id: variable
  parameters:
    value: '915'
  states: {}
- name: frf
  id: variable
  parameters:
    value: eb
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: lb
  id: variable
  parameters:
    value: 2*math.pi/sps/100
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pad_end
  id: variable
  parameters:
    value: '100'
  states: {}
- name: pad_start
  id: variable
  parameters:
    value: '100'
  states: {}
- name: pfs
  id: variable
  parameters:
    value: sps*2+1
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '31'
  states: {}
- name: rx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate / sps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 0.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0,samp_rate,samp_rate/sps,eb,11*sps)
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: tx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts
    sym_rate: '1.0'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-4'
    type: float
  states: {state: disabled}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: tx_eob
    false_value: 'True'
    true_key: tx_sob
    true_value: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/packet
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/payload_bytes
    type: byte
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: pfs
    rolloff: frf
    samps_per_sym: sps
    type: cc
    w: lb
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, verbose=False, addr=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Py Message Parser',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.data_in = "data_in"
              self.cmd_in = "cmd_in"
              self.addr = addr

              self.message_port_register_in(pmt.intern(self.cmd_in ))
              self.message_port_register_in(pmt.intern(self.data_in ))

              self.set_msg_handler(pmt.intern(self.data_in), self.handle_data)
              self.set_msg_handler(pmt.intern(self.cmd_in), self.handle_cmd)

              self.verbose = verbose
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.cnt = 0

          def handle_data(self, msg):
              a = pmt.to_python(msg)

              chars = a[1]
              addr = chars[:2]

              addr = 256*addr[0]+addr[1]

              if addr == self.addr:
                  return
              
              string_ = []
              for i in chars[2:]:
                  if i == 35:
                      if self.verbose:
                          print (chars)
                          string_.append("<ETX>")

                      break
                  
                  string_.append(chr(i))
              
              string_ = ''.join(string_)

              # if "Testing" in string_:
              self.cnt = self.cnt + 1

              # if not self.verbose:
              #     string_ = string_.split("<ETX>")[0]
              
              print (f"Rx message from {addr}: {a[1]}")
          
          def handle_cmd(self, msg):
              msg = pmt.to_python(msg)

          def handle_cmd(self, msg):
              msg = pmt.to_python(msg)
              
              try:
                  cmd = msg[1][0]
                  test = int(msg[1][1])
              except:
                  return

              if cmd == 1:
                  print ("Count = %d/%d" % (self.cnt, test))
                  self.cnt = 0

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              pass
    addr: '1'
    verbose: 'False'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, delay=10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Add TX Time Tag',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.usrp = None
              self.sample_count = 0

              self.tx_time_out = "tx_time_out"
              self.reset = "reset"

              self.message_port_register_out(pmt.intern(self.tx_time_out ))
              self.message_port_register_in(pmt.intern(self.reset ))

              self.set_msg_handler(pmt.intern(self.reset), self.handle_rst_msg)

              self.delay = delay 

              self.tx_secs = 0
              self.tx_fracs = 0
              self.call = 0
              self.set_eob = False
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.tx_time_set = False

          def handle_rst_msg(self, msg):
              reset_msg = pmt.to_python(msg)
              #print (reset_msg)

              if self.tx_time_set and reset_msg[1] and reset_msg[0] == 'reset':
                  self.tx_time_set = False
                  #print (self.tx_time_set)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              time = self.usrp.get_time_now()

              output_items[0][:] = input_items[0]
              self.call = self.call + 1

              #print (f"Call: {self.call}")

              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))

              if not self.tx_time_set:
                  self.tx_secs = int(time.get_real_secs())+self.delay
                  self.tx_fracs = time.get_real_secs() - int(time.get_real_secs())
                  self.tx_time_set = True
                  
                  for tag in tagTuple:
                      if pmt.to_python(tag.key) == "packet_len":
                          self.add_item_tag(0, tag.offset, pmt.intern('tx_time'), pmt.to_pmt((self.tx_secs, self.tx_fracs)))
                          self.add_item_tag(0, tag.offset, pmt.intern('tx_sob'), pmt.PMT_T)
                          #self.add_item_tag(0, 0, pmt.intern('packet_len'), tag.value)
                          self.packet_length = pmt.to_python(tag.value)
                          self.consumed_packets = 0
                          self.set_eob = True
                          
                          break

              if self.set_eob:
                  #print (self.consumed_packets, len(output_items[0]), self.sample_count + (self.packet_length - self.consumed_packets), self.packet_length)
                  if (self.consumed_packets + len(output_items[0])) >= self.packet_length:
                      self.add_item_tag(0, self.sample_count, pmt.intern('tx_eob'), pmt.PMT_T)
                      self.set_eob = False

                  self.consumed_packets = self.consumed_packets + len(output_items[0])

              pmt_msg = pmt.to_pmt(('tx_time', self.tx_secs+self.tx_fracs))
              self.message_port_pub(pmt.intern(self.tx_time_out ), pmt_msg)
              # if self.packet_length < self.consumed_packets and self.set_eob:
              #     self.add_item_tag(0, self.sample_count+self.packet_length, pmt.intern('tx_eob'), pmt.PMT_T)
              #     self.set_eob = False 3856 
              # else:
              #     self.consumed_packets = self.consumed_packets + len(output_items[0])

              # Add EOB at the end of buffer
                  
                  

             # print ("Key: " + pmt.to_python(tag.key) + " " + str(tag.offset) + " " + str(tag.value))

              # tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))

              # for tag in tagTuple:
              #     print ("Key: " + pmt.to_python(tag.key) + " " + str(tag.offset) + " " + str(tag.value))

              self.sample_count = self.sample_count + len(output_items[0])
              return len(output_items[0])
    delay: '1'
  states: {}
- name: epy_block_1_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, usrp=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Add RX Time Tag',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.usrp = usrp
              self.samp_time = 0
              self.sample_count = 0
              self.first_sample = False
              

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #time = self.usrp.get_time_now()
              #rx_time = time.get_real_secs()
              output_items[0][:] = input_items[0]
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))

              for tag in tagTuple:
                  if pmt.to_python(tag.key) == "rx_time":
                      self.frac_secs_samps = pmt.to_python(tag.value)[1] * 500e3
                      self.first_sample = True

              if self.first_sample:
                  self.samp_time = self.samp_time - self.frac_secs_samps
                  self.first_sample = False
              
              self.add_item_tag(0, self.sample_count, pmt.intern('rx_samp_count'), pmt.to_pmt(self.samp_time))
      	
              self.sample_count = self.sample_count + len(output_items[0])
              self.samp_time = self.samp_time + len(output_items[0])
              return len(output_items[0])
    usrp: '0'
  states: {}
- name: epy_block_1_1_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport pmt\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, samp_rate=1e6, pad_end=0, pad_start=0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Compare Timestamps',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.samp_rate = samp_rate\n        self.sample_count = 0\n\n        self.tx_time_in = \"tx_time_in\"\n        self.reset = \"reset\"\n\n        self.message_port_register_in(pmt.intern(self.tx_time_in))\n        self.message_port_register_in(pmt.intern(self.reset))\n\n        self.set_msg_handler(pmt.intern(self.tx_time_in), self.handle_msg)\n        self.set_msg_handler(pmt.intern(self.reset), self.handle_rst_msg)\n\n        self.tx_time_set = False\n        self.rx_samp_count_set = False\n        self.corr_time_set = False\n        self.frac_set = False\n\n        self.tx_time = []\n        self.rx_time = 0\n\n        self.pad_end = pad_end\n        self.pad_start = pad_start\n        \n        with open(\"./rx_tx_timestamps.csv\",\"w\") as f:\n            f.write(\"id,tx_time, rx_samp_count, corr_index, frac_sample, rx_time, dt\\n\")\n\t     \n        self.id = 0\n\n    def handle_msg(self, msg):\n        tx_time = pmt.to_python(msg)\n        if not self.tx_time_set:\n            self.tx_time = tx_time[1] + (self.pad_start/self.samp_rate)\n            self.tx_time_set = True\n            # with open(\"./rx_tx_timestamps.csv\",\"a\") as f:\n            #     f.write(f\"{self.id},t,{self.tx_time}\\n\")\n\n    def handle_rst_msg(self, msg):\n        reset_msg = pmt.to_python(msg)\n        \n        if self.rx_samp_count_set and reset_msg[1] == 1 and reset_msg[0] == 'reset':\n            self.rx_samp_count_set = False\n            self.tx_time_set = False\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        \n        self.sample_count = self.sample_count + len(input_items[0])\n        tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))\n\n        if not self.rx_samp_count_set:\n            for tag in tagTuple:\n                if pmt.to_python(tag.key) == \"rx_samp_count\" and not self.rx_samp_count_set:\n                    self.rx_samp_count_set = True\n                    self.rx_samp_count = pmt.to_double(tag.value)\n            \n                if pmt.to_python(tag.key) == \"corr_index\" and not self.corr_time_set:\n                    self.corr_time_set = True                  \n                    #self.corr_time = (pmt.to_double(tag.value) * 2)/ self.samp_rate\n                    self.corr_time = pmt.to_double(tag.value)\n\n                if pmt.to_python(tag.key) == \"time_est3\" and not self.frac_set:\n                    self.frac_set = True\n                    #self.corr_time = (pmt.to_double(tag.value) * 2)/ self.samp_rate\n                    self.frac = pmt.to_double(tag.value)\n            \n            #print (self.tx_time_set, self.corr_time_set, self.frac_set)\n\n            if self.tx_time_set and self.corr_time_set and self.frac_set:\n                with open(\"./rx_tx_timestamps.csv\",\"a\") as f:\n                    self.rx_time = (self.rx_samp_count + self.corr_time + self.frac)/ 500e3 #self.rx_time - self.corr_time\n                    f.write(f\"{self.id},{self.tx_time},{self.rx_samp_count},{self.corr_time},{self.frac},{self.rx_time},{self.rx_time - self.tx_time}\\n\")\n                    \n                self.tx_time_set = False\n                self.corr_time_set = False\n                self.frac_set = False\n                self.id = self.id + 1\n            \n        return len(input_items[0])\n\n"
    pad_end: pad_end
    pad_start: pad_start
    samp_rate: samp_rate
  states: {}
- name: epy_block_1_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, display_value=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag Dump (Unique only)',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.tags = []
              self.display_value = display_value
              self.call = 0
              
          
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))
              self.call = self.call + 1


              for tag in tagTuple:
                  if pmt.to_python(tag.key) not in self.tags:
                      self.tags.append(pmt.to_python(tag.key))

                      if self.display_value:
                          print (str(self.call)+ " :Key: " + pmt.to_python(tag.key) + " " + str(tag.offset) + " " + str(tag.value))
                      else:
                          print ("Key: " + pmt.to_python(tag.key))

                      #rtt = self.rx_time - self.tx_time
                      #print (f"Rx time: {self.rx_time}")
                      #print (f"Tx time: {self.tx_time}")
                      #print (f"\n\nRTT: {rtt}s")
              return 0
    display_value: 'True'
  states: {state: disabled}
- name: epy_block_1_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, display_value=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag Dump (Unique only)',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.tags = []
              self.display_value = display_value
              self.time_est = "time_est"
              self.message_port_register_out(pmt.intern(self.time_est))

          
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))

              for tag in tagTuple:
                  if pmt.to_python(tag.key) not in self.tags:
                      self.tags.append(pmt.to_python(tag.key))
                      if pmt.to_python(tag.key) == "corr_est":
                          print (f"Key: {pmt.to_python(tag.key)} {str(tag.offset)} {str(tag.value)}: Time {float(pmt.to_python(tag.value))/500e3}")

                      if self.display_value:
                          print (f"Key: {pmt.to_python(tag.key)} {str(tag.offset)} {str(tag.value)}")
                      else:
                          print ("Key: " + pmt.to_python(tag.key))

                  if pmt.to_python(tag.key) == "time_est":
                      pmt_msg = pmt.to_pmt(('time_est', pmt.to_python(tag.value)))
                      self.message_port_pub(pmt.intern(self.time_est), pmt_msg)
                      #rtt = self.rx_time - self.tx_time
                      #print (f"Rx time: {self.rx_time}")
                      #print (f"Tx time: {self.tx _time}")
                      #print (f"\n\nRTT: {rtt}s")

              output_items[0][:] = input_items[0]
              return len(output_items[0])
    display_value: 'True'
  states: {state: disabled}
- name: epy_block_1_1_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, display_value=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag Dump (Unique only)',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.tags = []
              self.display_value = display_value
          
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))

              for tag in tagTuple:
                  if pmt.to_python(tag.key) not in self.tags:
                      self.tags.append(pmt.to_python(tag.key))

                      if self.display_value:
                          print ("Key: " + pmt.to_python(tag.key) + " " + str(tag.offset) + " " + str(tag.value))
                      else:
                          print ("Key: " + pmt.to_python(tag.key))

                      #rtt = self.rx_time - self.tx_time
                      #print (f"Rx time: {self.rx_time}")
                      #print (f"Tx time: {self.tx_time}")
                      #print (f"\n\nRTT: {rtt}s")
              return 0
    display_value: 'True'
  states: {state: disabled}
- name: epy_block_1_1_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, display_value=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag Dump (Unique only)',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.tags = []
              self.display_value = display_value
          
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))

              for tag in tagTuple:
                  if pmt.to_python(tag.key) not in self.tags:
                      self.tags.append(pmt.to_python(tag.key))

                      if self.display_value:
                          print ("Key: " + pmt.to_python(tag.key) + " " + str(tag.offset) + " " + str(tag.value))
                      else:
                          print ("Key: " + pmt.to_python(tag.key))

                      #rtt = self.rx_time - self.tx_time
                      #print (f"Rx time: {self.rx_time}")
                      #print (f"Tx time: {self.tx_time}")
                      #print (f"\n\nRTT: {rtt}s")
              return 0
    display_value: 'True'
  states: {state: disabled}
- name: epy_block_1_1_0_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, display_value=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag Dump (Unique only)',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.tags = []
              self.display_value = display_value
              self.id = 0
          
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0]
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))

              for tag in tagTuple:
                  if not pmt.to_python(tag.key) == "rx_samp_count": # not in self.tags:
                      self.tags.append(pmt.to_python(tag.key))

                      if self.display_value:
                          print (str(self.id) + ": Key: " + pmt.to_python(tag.key) + " " + str(tag.offset) + " " + str(tag.value))
                      else:
                          print ("Key: " + pmt.to_python(tag.key))

                      #rtt = self.rx_time - self.tx_time
                      #print (f"Rx time: {self.rx_time}")
                      #print (f"Tx time: {self.tx_time}")
                      #print (f"\n\nRTT: {rtt}s")
              
              self.id = self.id + 1
              return len(output_items[0])
    display_value: 'True'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: packet_rx_0
  id: packet_rx
  parameters:
    eb: eb
    hdr_const: Const_HDR
    hdr_dec: dec_hdr
    hdr_format: hdr_format
    pld_const: Const_PLD
    pld_dec: dec
    psf_taps: rx_rrc_taps
    sps: sps
  states: {}
- name: packet_tx_0
  id: packet_tx
  parameters:
    hdr_const: Const_HDR
    hdr_enc: enc_hdr
    hdr_format: hdr_format
    pad_end: pad_end
    pad_start: pad_start
    pld_const: Const_PLD
    pld_enc: enc
    psf_taps: tx_rrc_taps
    sps: sps
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"TX"'
    size: int(samp_rate/100)
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"RX"'
    size: int(samp_rate/100) *2
    srate: samp_rate
    tr_delay: '0.0055'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Correlation"'
    size: int(samp_rate/100) *2
    srate: samp_rate
    tr_delay: '0.001'
    tr_level: '100'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_start"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '20240'
    srate: samp_rate
    tr_delay: '0.0005'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"tx_eob"'
    type: complex
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: eb
    decim: '1'
    gain: '2'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.epy_block_1.usrp = self.uhd_usrp_sink_0
      self.epy_block_1_1.usrp = self.uhd_usrp_sink_0
      self.uhd_usrp_sink_0.set_time_next_pps(uhd.time_spec(0.0))
      self.uhd_usrp_source_0.set_time_next_pps(uhd.time_spec(0.0))
    section: main_after_init
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq * 1e6
    dev_args: '"serial=31EABEA, underflow_policy=next_packet"'
    gain0: tx_gain-10
    len_tag_name: ''
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq*1e6
    dev_args: '"serial=31EABEA"'
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: a
  states: {state: disabled}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:1234
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:1237
    timeout: '100'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_float_to_short_0, '0']
- [blocks_burst_tagger_0, '0', epy_block_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_message_strobe_0, strobe, packet_tx_0, in]
- [blocks_multiply_const_vxx_0, '0', blocks_burst_tagger_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_1, '0']
- [blocks_multiply_const_vxx_0, '0', epy_block_1, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [epy_block_1, '0', blocks_throttle2_0, '0']
- [epy_block_1, '0', epy_block_1_1_0_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_1, '0']
- [epy_block_1, '0', uhd_usrp_sink_0, '0']
- [epy_block_1, tx_time_out, epy_block_1_1_0, tx_time_in]
- [epy_block_1_1, '0', digital_fll_band_edge_cc_0, '0']
- [epy_block_1_1, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_1_1_0_0_0, '0', blocks_complex_to_mag_0, '0']
- [epy_block_1_1_0_0_0, '0', blocks_null_sink_1, '0']
- [epy_block_1_1_0_0_0_0_0_0, '0', epy_block_1_1_0, '0']
- [packet_rx_0, '0', epy_block_1_1_0, '0']
- [packet_rx_0, '0', epy_block_1_1_0_0_0_0_0, '0']
- [packet_rx_0, '0', epy_block_1_1_0_0_0_0_0_0, '0']
- [packet_rx_0, '1', epy_block_1_1_0_0_0, '0']
- [packet_rx_0, '1', epy_block_1_1_0_0_0_0, '0']
- [packet_rx_0, payload, blocks_message_debug_0, print_pdu]
- [packet_rx_0, precrc, epy_block_0, data_in]
- [packet_rx_0, precrc, pdu_pdu_to_stream_x_0, pdus]
- [packet_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0_0, '0']
- [root_raised_cosine_filter_0, '0', packet_rx_0, '0']
- [uhd_usrp_sink_0, async_msgs, blocks_message_debug_0_0, print_pdu]
- [uhd_usrp_source_0, '0', epy_block_1_1, '0']
- [virtual_source_0, '0', epy_block_1_1, '0']
- [zeromq_pull_msg_source_0, out, packet_tx_0, in]
- [zeromq_pull_msg_source_0_0, out, epy_block_0, cmd_in]
- [zeromq_pull_msg_source_0_0, out, epy_block_1, reset]
- [zeromq_pull_msg_source_0_0, out, epy_block_1_1_0, reset]

metadata:
  file_format: 1
  grc_version: gfe42f6a4a
