options:
  parameters:
    generate_options: no_gui
    id: uhd_bpsk_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Const_HDR
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: amp
  id: variable
  parameters:
    value: '21.5'
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: BB RF Gain
    start: '0'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {state: disabled}
- name: bb_gain
  id: variable
  parameters:
    value: '2.6'
  states: {}
- name: dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec_hdr
  id: variable_repetition_decoder_def
  parameters:
    framebits: hdr_format.header_nbits()
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.6'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '915'
  states: {}
- name: freq_tune
  id: variable
  parameters:
    value: '-900'
  states: {}
- name: freq_tune
  id: variable_qtgui_range
  parameters:
    label: Freq tune
    start: '-10e3'
    step: '10'
    stop: 10e3
    value: '-6852'
  states: {state: disabled}
- name: frf
  id: variable
  parameters:
    value: eb
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '68'
  states: {state: disabled}
- name: gain
  id: variable
  parameters:
    value: '67'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: lb
  id: variable
  parameters:
    value: 2*math.pi/sps/100
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pfs
  id: variable
  parameters:
    value: sps*2+1
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '31'
  states: {}
- name: rx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate / sps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 0.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: pfs
    rolloff: frf
    samps_per_sym: sps
    type: cc
    w: lb
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, verbose=False, addr=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Py Message Parser',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.data_in = "data_in"
              self.cmd_in = "cmd_in"
              self.addr = addr

              self.message_port_register_in(pmt.intern(self.cmd_in ))
              self.message_port_register_in(pmt.intern(self.data_in ))

              self.set_msg_handler(pmt.intern(self.data_in), self.handle_data)
              self.set_msg_handler(pmt.intern(self.cmd_in), self.handle_cmd)

              self.verbose = verbose
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.cnt = 0

          def handle_data(self, msg):
              a = pmt.to_python(msg)

              chars = a[1]
              addr = chars[:2]

              addr = 256*addr[0]+addr[1]

              if addr == self.addr:
                  return
              
              string_ = []
              for i in chars[2:]:
                  if i == 35:
                      if self.verbose:
                          print (chars)
                          string_.append("<ETX>")

                      break
                  
                  string_.append(chr(i))
              
              string_ = ''.join(string_)

              # if "Testing" in string_:
              self.cnt = self.cnt + 1

              # if not self.verbose:
              #     string_ = string_.split("<ETX>")[0]
              
              print (f"Rx message from {addr}: {a[1]}")
          
          def handle_cmd(self, msg):
              msg = pmt.to_python(msg)

          def handle_cmd(self, msg):
              msg = pmt.to_python(msg)
              
              try:
                  cmd = msg[1][0]
                  test = int(msg[1][1])
              except:
                  return

              if cmd == 1:
                  print ("Count = %d/%d" % (self.cnt, test))
                  self.cnt = 0

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              pass
    addr: '2'
    verbose: 'False'
  states: {}
- name: epy_block_1_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, usrp=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Add RX Time Tag',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.usrp = usrp
              self.samp_time = 0
              self.sample_count = 0
              self.first_sample = False
              

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #time = self.usrp.get_time_now()
              #rx_time = time.get_real_secs()
              output_items[0][:] = input_items[0]
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))

              for tag in tagTuple:
                  if pmt.to_python(tag.key) == "rx_time":
                      self.frac_secs_samps = pmt.to_python(tag.value)[1] * 500e3
                      self.first_sample = True

              if self.first_sample:
                  self.samp_time = self.samp_time - self.frac_secs_samps
                  self.first_sample = False
              
              self.add_item_tag(0, self.sample_count, pmt.intern('rx_samp_count'), pmt.to_pmt(self.samp_time))
      	
              self.sample_count = self.sample_count + len(output_items[0])
              self.samp_time = self.samp_time + len(output_items[0])
              return len(output_items[0])
    usrp: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: packet_rx_0
  id: packet_rx
  parameters:
    eb: eb
    hdr_const: Const_HDR
    hdr_dec: dec_hdr
    hdr_format: hdr_format
    pld_const: Const_PLD
    pld_dec: dec
    psf_taps: rx_rrc_taps
    sps: sps
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq*1e6 + freq_tune
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"At RF In"'
    size: '5240'
    srate: samp_rate
    tr_delay: '0.0005'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Data"'
    size: '1024'
    srate: samp_rate
    tr_delay: '0.005'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: eb
    decim: '1'
    gain: bb_gain
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq*1e6 + freq_tune
    gain0: gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [epy_block_1_1, '0', digital_fll_band_edge_cc_0, '0']
- [packet_rx_0, '0', qtgui_time_sink_x_1, '0']
- [packet_rx_0, pkt out, epy_block_0, data_in]
- [packet_rx_0, precrc, blocks_message_debug_0, print_pdu]
- [packet_rx_0, precrc, epy_block_0, data_in]
- [root_raised_cosine_filter_0, '0', packet_rx_0, '0']
- [uhd_usrp_source_0, '0', epy_block_1_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-551-ge2f14775
