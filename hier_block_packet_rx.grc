options:
  parameters:
    category: Packet Operators
    generate_options: hb
    id: packet_rx
    output_language: python
  states: {}

blocks:
- name: mark_delay
  id: variable
  parameters:
    value: mark_delays[sps]
  states: {}
- name: mark_delays
  id: variable
  parameters:
    comment: |-
      Tag Marking Delay for 
      Corr Est block, indexed
      by sps.

      Found empirically.
    value: '[0, 0, 34, 56, 87, 119]'
  states: {}
- name: modulated_sync_word
  id: variable_modulate_vector
  parameters:
    data: preamble
    mod: rxmod
    taps: '[1]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: preamble_select[int(1.0/hdr_dec.rate())]
  states: {}
- name: preamble_dummy
  id: variable
  parameters:
    comment: |-
      use when header
      FEC is Dummy
    value: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
  states: {}
- name: preamble_rep
  id: variable
  parameters:
    comment: |-
      use when header
      FEC is Repetition (x3)
    value: '[0xe3, 0x8f, 0xc0, 0xfc, 0x7f, 0xc7, 0xe3, 0x81, 0xc0, 0xff, 0x80, 0x38, 0xff, 0xf0, 0x38, 0xe0, 0x0f, 0xc0, 0x03, 0x80, 0x00, 0xff, 0xff, 0xc0]'
  states: {}
- name: preamble_select
  id: variable
  parameters:
    value: '{1: preamble_dummy, 3: preamble_rep}'
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(hdr_const, False, sps, True, eb, False, False)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/payload
    type: int
  states: {state: disabled}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_multiply_by_tag_value_cc_0
  id: blocks_multiply_by_tag_value_cc
  parameters:
    tagname: '"amp_est"'
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"rx_time2"'
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"time_est2"'
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: pld_const.bits_per_symbol()
    lengthtagname: '"payload symbols"'
    type: float
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: pld_const
    npwr: '-1'
  states: {}
- name: digital_constellation_soft_decoder_cf_0_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: hdr_const
    npwr: '-1'
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: mark_delay
    sps: sps
    symbols: modulated_sync_word
    threshold: '0.9999'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: hdr_const.arity()
    w: 2*math.pi/sps/100
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: pld_const.arity()
    w: 2*math.pi/sps/100
  states: {}
- name: digital_costas_loop_cc_0_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: pld_const.arity()
    w: 2*math.pi/sps/100
  states: {state: disabled}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: (hdr_format.header_nbits() * int(1.0/hdr_dec.rate())) //  hdr_const.bits_per_symbol()
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"payload symbols"'
    output_symbols: 'True'
    samp_rate: '1'
    special_tags: '["time_est3"]'
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"time_est"'
    type: complex
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/400.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: psf_taps
    type: ccf
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    pfb_mf_taps: psf_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {state: disabled}
- name: eb
  id: parameter
  parameters:
    label: Filter Rolloff
    type: eng_float
    value: '0.35'
  states: {}
- name: epy_block_1_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Add RX Time Tag',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sample_count = 0

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #time = self.usrp.get_time_now()
              #rx_time = time.get_real_secs()
              output_items[0][:] = input_items[0]
              
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))

              for tag in tagTuple:
                  if pmt.to_python(tag.key) == "time_est":
                      self.add_item_tag(0, self.sample_count, pmt.intern('time_est3'), tag.value)
                      	
              self.sample_count = self.sample_count + len(output_items[0])
              return len(output_items[0])
  states: {}
- name: epy_block_1_1_0_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, display_value=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag Dump (Unique only)',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.tags = []
              self.display_value = display_value
          
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))

              for tag in tagTuple:
                  if pmt.to_python(tag.key) not in self.tags:
                      self.tags.append(pmt.to_python(tag.key))

                      if self.display_value:
                          print ("Key: " + pmt.to_python(tag.key) + " " + str(tag.offset) + " " + str(tag.value))
                      else:
                          print ("Key: " + pmt.to_python(tag.key))

                      #rtt = self.rx_time - self.tx_time
                      #print (f"Rx time: {self.rx_time}")
                      #print (f"Tx time: {self.tx_time}")
                      #print (f"\n\nRTT: {rtt}s")
              return 0
    display_value: 'True'
  states: {state: disabled}
- name: epy_block_1_1_0_0_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, display_value=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tag Dump (Unique only)',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.tags = []
              self.display_value = display_value
              self.id = 0
          
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0]
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))

              for tag in tagTuple:
                  if not pmt.to_python(tag.key) == "rx_samp_count": # not in self.tags:
                      self.tags.append(pmt.to_python(tag.key))

                      if self.display_value:
                          print (str(self.id) + ": Key: " + pmt.to_python(tag.key) + " " + str(tag.offset) + " " + str(tag.value))
                      else:
                          print ("Key: " + pmt.to_python(tag.key))

                      #rtt = self.rx_time - self.tx_time
                      #print (f"Rx time: {self.rx_time}")
                      #print (f"Tx time: {self.tx_time}")
                      #print (f"\n\nRTT: {rtt}s")
              
              self.id = self.id + 1
              return len(output_items[0])
    display_value: 'True'
  states: {state: disabled}
- name: fec_async_decoder_0
  id: fec_async_decoder
  parameters:
    decoder: pld_dec
    mtu: 1500*8
    packed: 'True'
    rev_pack: 'False'
  states: {}
- name: fec_generic_decoder_0
  id: fec_generic_decoder
  parameters:
    decoder: hdr_dec
    itype: float
    otype: byte
  states: {}
- name: hdr_const
  id: parameter
  parameters:
    label: Header constellation
    value: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
  states: {}
- name: hdr_dec
  id: parameter
  parameters:
    label: Header FEC Decoder
    value: ' fec.dummy_decoder.make(8000)'
  states: {}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pkt out
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: precrc
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: proto_parse
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1_0_0
  id: pad_sink
  parameters:
    label: payload
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: hdr_out
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: pld_out
    optional: 'True'
    type: complex
  states: {state: disabled}
- name: pad_sink_3_0
  id: pad_sink
  parameters:
    label: pld_phs
    optional: 'True'
    type: complex
  states: {state: disabled}
- name: pad_sink_5
  id: pad_sink
  parameters:
    label: timing
    optional: 'True'
    type: complex
  states: {state: disabled}
- name: pad_sink_7
  id: pad_sink
  parameters:
    label: corr est
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"payload symbols"'
    type: float
  states: {}
- name: pld_const
  id: parameter
  parameters:
    label: Payload constellation
    value: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
  states: {}
- name: pld_dec
  id: parameter
  parameters:
    label: Payload FEC Decoder
    value: ' fec.dummy_decoder.make(8000)'
  states: {}
- name: psf_taps
  id: parameter
  parameters:
    label: Pulse Shape Filter
    value: '[0,]'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: eng_float
    value: '2'
  states: {}

connections:
- [blocks_float_to_int_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_by_tag_value_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_multiply_by_tag_value_cc_0, '0', epy_block_1_1, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_float_to_int_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_float_to_short_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_constellation_soft_decoder_cf_0_0, '0', fec_generic_decoder_0, '0']
- [digital_corr_est_cc_0, '0', blocks_multiply_by_tag_value_cc_0, '0']
- [digital_corr_est_cc_0, '1', pad_sink_7, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_tag_debug_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', blocks_tag_debug_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_soft_decoder_cf_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', pad_sink_2, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', pad_sink_3_0, '0']
- [digital_costas_loop_cc_0_0_0_0, '0', digital_header_payload_demux_0, '0']
- [digital_costas_loop_cc_0_0_0_0, '0', pad_sink_5, '0']
- [digital_crc_check_0, fail, pad_sink_1, in]
- [digital_crc_check_0, ok, pad_sink_0, in]
- [digital_header_payload_demux_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_header_payload_demux_0, '1', digital_costas_loop_cc_0_0_0, '0']
- [digital_header_payload_demux_0, '1', epy_block_1_1_0_0_0_0_0_0_0, '0']
- [digital_header_payload_demux_0, '1', pad_sink_3, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_header_payload_demux_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', epy_block_1_1_0_0_0_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', pad_sink_5, '0']
- [digital_protocol_parser_b_0, info, digital_header_payload_demux_0, header_data]
- [digital_protocol_parser_b_0, info, pad_sink_1_0, in]
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_header_payload_demux_0, '0']
- [digital_symbol_sync_xx_0, '0', pad_sink_5, '0']
- [epy_block_1_1, '0', digital_pfb_clock_sync_xxx_0, '0']
- [epy_block_1_1_0_0_0_0_0_0_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [fec_async_decoder_0, out, digital_crc_check_0, in]
- [fec_generic_decoder_0, '0', digital_protocol_parser_b_0, '0']
- [pad_source_0, '0', digital_corr_est_cc_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, fec_async_decoder_0, in]
- [pdu_tagged_stream_to_pdu_0, pdus, pad_sink_1_0_0, in]

metadata:
  file_format: 1
  grc_version: gfe42f6a4a
