options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: uhd_packet_tx
    output_language: python
  states: {}

blocks:
- name: Const_HDR
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    start: '0'
    step: '0.01'
    stop: '2'
    value: '1.0'
  states: {state: disabled}
- name: amp
  id: variable
  parameters:
    value: '21.5'
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.6'
  states: {}
- name: enc
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {state: disabled}
- name: enc
  id: variable_cc_encoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: enc_hdr
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: enc_hdr
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Tx Freq
    start: '433'
    step: '0.05'
    stop: '934'
    value: '915'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '915'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Freq. Offset
    start: '-0.5'
    step: '0.0001'
    stop: '0.5'
    value: '0'
  states: {state: disabled}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Noise Amp
    start: '0'
    step: '0.01'
    stop: '5'
    value: '0.0'
  states: {state: disabled}
- name: pad_end
  id: variable_qtgui_range
  parameters:
    label: Padding End
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '100'
  states: {state: disabled}
- name: pad_end
  id: variable
  parameters:
    value: '100'
  states: {}
- name: pad_start
  id: variable_qtgui_range
  parameters:
    label: Padding Start
    rangeType: int
    start: '0'
    step: '1'
    stop: '10000'
    value: '100'
  states: {state: disabled}
- name: pad_start
  id: variable
  parameters:
    value: '100'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0,samp_rate,samp_rate/sps,eb,11*sps)
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Time Offset
    start: '0.99'
    step: '0.00001'
    stop: '1.01'
    value: '1.0'
  states: {state: disabled}
- name: tx_gain
  id: variable
  parameters:
    value: '68'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx Gain
    start: '0'
    step: '0.1'
    stop: '70'
    value: '55'
  states: {state: disabled}
- name: tx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts
    sym_rate: '1.0'
  states: {}
- name: tx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate / sps
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/bpsk_tx_debug.cfile
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6'
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Py Message Parser',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.port_in = "data_in"
              self.message_port_register_in(pmt.intern(self.port_in ))
              self.set_msg_handler(pmt.intern(self.port_in), self.handle_msg)

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def handle_msg(self, msg):
              a = pmt.to_python(msg)
              chars = a[1]

              print (chars)
              
              string_ = []
              for i in chars:
                  if i == 35:
                      string_.append("<ETX>")
                      break
                  
                  string_.append(chr(i))
              
              print (''.join(string_))
              
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              pass
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: taps
    type: ccc
  states: {state: disabled}
- name: packet_tx_0
  id: packet_tx
  parameters:
    hdr_const: Const_HDR
    hdr_enc: enc_hdr
    hdr_format: hdr_format
    pad_end: pad_end
    pad_start: pad_start
    pld_const: Const_PLD
    pld_enc: enc
    psf_taps: tx_rrc_taps
    sps: sps
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq * 1e6
    clock_source0: internal
    dev_args: '"serial=31BADAB"'
    gain0: tx_gain
    len_tag_name: packet_len
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:1234
    timeout: '100'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:1235
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [channels_channel_model_0, '0', zeromq_push_sink_0, '0']
- [fir_filter_xxx_0, '0', uhd_usrp_sink_0, '0']
- [packet_tx_0, '0', blocks_file_sink_0, '0']
- [packet_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [packet_tx_0, '0', blocks_tag_debug_0, '0']
- [packet_tx_0, '0', channels_channel_model_0, '0']
- [packet_tx_0, '0', fir_filter_xxx_0, '0']
- [packet_tx_0, postcrc, blocks_message_debug_0, print_pdu]
- [packet_tx_0, postcrc, epy_block_0, data_in]
- [zeromq_pull_msg_source_0, out, packet_tx_0, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-489-g76831245
