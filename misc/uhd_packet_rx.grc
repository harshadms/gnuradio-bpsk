options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: uhd_packet_rx
    output_language: python
  states: {}

blocks:
- name: Const_HDR
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    start: '0'
    step: '0.1'
    stop: '100'
    value: '19'
  states: {state: disabled}
- name: amp
  id: variable
  parameters:
    value: '21.5'
  states: {}
- name: dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec_hdr
  id: variable_repetition_decoder_def
  parameters:
    framebits: hdr_format.header_nbits()
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.6'
  states: {}
- name: enc
  id: variable_cc_encoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: enc_hdr
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Receiver Frequency
    start: '433'
    step: '0.05'
    stop: '434'
    value: '433.6'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '915'
  states: {}
- name: frf
  id: variable_qtgui_range
  parameters:
    label: Filter Rolloff Factor
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.22'
  states: {state: disabled}
- name: frf
  id: variable
  parameters:
    value: eb
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: lb
  id: variable_qtgui_range
  parameters:
    label: Loop Bandwidth
    start: '0'
    step: '0.001'
    stop: '1'
    value: 2*math.pi/sps/100
  states: {state: disabled}
- name: lb
  id: variable
  parameters:
    value: 2*math.pi/sps/100
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pfs
  id: variable_qtgui_range
  parameters:
    label: Prototype Filter Size
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: sps*2+1
  states: {state: disabled}
- name: pfs
  id: variable
  parameters:
    value: sps*2+1
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: radps
  id: variable_qtgui_range
  parameters:
    label: Prototype Filter Size
    start: '0'
    step: '0.001'
    stop: '3.14'
    value: '0.002'
  states: {state: disabled}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Receiver Gain
    start: '0'
    step: '0.1'
    stop: '31.5'
    value: '29'
  states: {state: disabled}
- name: rx_gain
  id: variable
  parameters:
    value: '31'
  states: {}
- name: rx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate / sps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: '0.18'
    min_freq: '-0.18'
    w: lb
  states: {state: disabled}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp
    type: complex
  states: {state: bypassed}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp
    type: complex
  states: {state: disabled}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: pfs
    rolloff: frf
    samps_per_sym: sps
    type: cc
    w: lb
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, verbose=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Py Message Parser',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.data_in = "data_in"
              self.cmd_in = "cmd_in"
              
              self.message_port_register_in(pmt.intern(self.cmd_in ))
              self.message_port_register_in(pmt.intern(self.data_in ))

              self.set_msg_handler(pmt.intern(self.data_in), self.handle_data)
              self.set_msg_handler(pmt.intern(self.cmd_in), self.handle_cmd)

              self.verbose = verbose
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.cnt = 0

          def handle_data(self, msg):
              a = pmt.to_python(msg)
              chars = a[1]

              string_ = []
              for i in chars:
                  if i == 35:
                      if self.verbose:
                          print (chars)
                          string_.append("<ETX>")

                      break
                  
                  string_.append(chr(i))
              
              string_ = ''.join(string_)

              if "Testing" in string_:
                  self.cnt = self.cnt + 1

              if not self.verbose:
                  string_ = string_.split("<ETX>")[0]

              print (f"Rx message: {string_}")
          
          def handle_cmd(self, msg):
              msg = pmt.to_python(msg)
              cmd = msg[1][0]
              test = int(msg[1][1])

              if cmd == 1:
                  print ("Count = %d/%d" % (self.cnt, test))
                  self.cnt = 0
                         

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              pass
    verbose: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: packet_rx_0
  id: packet_rx
  parameters:
    eb: eb
    hdr_const: Const_HDR
    hdr_dec: dec_hdr
    hdr_format: hdr_format
    pld_const: Const_PLD
    pld_dec: dec
    psf_taps: rx_rrc_taps
    sps: sps
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab1@2
    legend: 'False'
    size: '800'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    gui_hint: tab1@1
    legend: 'False'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab0@0
    name: '"FLL + PLL"'
    size: '1500'
    srate: samp_rate
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab0@0
    name: '"FLL"'
    size: '1500'
    srate: samp_rate
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab0@0
    label1: Raw
    label2: FLL
    name: '"FLL"'
    nconnections: '2'
    size: '1500'
    srate: samp_rate
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab0@0
    name: '"Raw"'
    size: '1500'
    srate: samp_rate
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab1@0
    label1: ''
    label2: ''
    legend: 'False'
    name: '"Correlation Est"'
    size: '1250'
    srate: samp_rate
    tr_delay: '50'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
    ylabel: Correlation
    ymax: '150'
    ymin: '-150'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab1@0
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '0'
    name: '"Packet"'
    size: '200'
    srate: '1'
    style1: '3'
    tr_delay: '25'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"payload symbols"'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: eb
    decim: '1'
    gain: amp/5
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,1,1,1
    label0: Rx Time
    label1: Rx Freq.
    label2: Rx Const.
    num_tabs: '3'
  states: {state: disabled}
- name: tab1
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: Pkt Time
    label1: Pkt Freq.
    label2: Pkt Const.
    num_tabs: '3'
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq*1e6
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:1237
    timeout: '100'
  states: {}
- name: zeromq_pull_source_0_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:1235
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_pll_refout_cc_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', packet_rx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', root_raised_cosine_filter_0, '0']
- [packet_rx_0, '1', qtgui_const_sink_x_0_0_0, '0']
- [packet_rx_0, '1', qtgui_freq_sink_x_0_0, '0']
- [packet_rx_0, '1', qtgui_time_sink_x_1_0_0_1, '0']
- [packet_rx_0, '4', qtgui_time_sink_x_1_0_0_0, '0']
- [packet_rx_0, precrc, blocks_message_debug_0_0_0, print_pdu]
- [packet_rx_0, precrc, epy_block_0, data_in]
- [root_raised_cosine_filter_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [uhd_usrp_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [zeromq_pull_msg_source_0, out, epy_block_0, cmd_in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-489-g76831245
