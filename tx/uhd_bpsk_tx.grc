options:
  parameters:
    author: harshad
    generate_options: no_gui
    id: uhd_bpsk_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Const_HDR
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.6'
  states: {}
- name: enc
  id: variable_cc_encoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: enc_hdr
  id: variable_repetition_encoder_def
  parameters:
    framebits: '128'
    ndim: '0'
    rep: rep
  states: {}
- name: freq
  id: variable
  parameters:
    value: '915'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pad_end
  id: variable
  parameters:
    value: '100'
  states: {}
- name: pad_start
  id: variable
  parameters:
    value: '100'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 0.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0,samp_rate,samp_rate/sps,eb,11*sps)
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: tx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts
    sym_rate: '1.0'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, verbose=False, addr=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Py Message Parser',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.data_in = "data_in"
              self.cmd_in = "cmd_in"
              self.addr = addr

              self.message_port_register_in(pmt.intern(self.cmd_in ))
              self.message_port_register_in(pmt.intern(self.data_in ))

              self.set_msg_handler(pmt.intern(self.data_in), self.handle_data)
              self.set_msg_handler(pmt.intern(self.cmd_in), self.handle_cmd)

              self.verbose = verbose
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.cnt = 0

          def handle_data(self, msg):
              a = pmt.to_python(msg)

              chars = a[1]
              addr = chars[:2]

              addr = 256*addr[0]+addr[1]

              if addr == self.addr:
                  return
              
              string_ = []
              for i in chars[2:]:
                  if i == 35:
                      if self.verbose:
                          print (chars)
                          string_.append("<ETX>")

                      break
                  
                  string_.append(chr(i))
              
              string_ = ''.join(string_)

              # if "Testing" in string_:
              self.cnt = self.cnt + 1

              # if not self.verbose:
              #     string_ = string_.split("<ETX>")[0]
              
              print (f"Rx message from {addr}: {a[1]}")
          
          def handle_cmd(self, msg):
              msg = pmt.to_python(msg)

          def handle_cmd(self, msg):
              msg = pmt.to_python(msg)
              
              try:
                  cmd = msg[1][0]
                  test = int(msg[1][1])
              except:
                  return

              if cmd == 1:
                  print ("Count = %d/%d" % (self.cnt, test))
                  self.cnt = 0

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              pass
    addr: '1'
    verbose: 'False'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, delay=10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Add TX Time Tag',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.usrp = None
              self.sample_count = 0

              self.tx_time_out = "tx_time_out"
              self.reset = "reset"

              self.message_port_register_out(pmt.intern(self.tx_time_out ))
              self.message_port_register_in(pmt.intern(self.reset ))

              self.set_msg_handler(pmt.intern(self.reset), self.handle_rst_msg)

              self.delay = delay 

              self.tx_secs = 0
              self.tx_fracs = 0
              self.call = 0
              self.set_eob = False
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.tx_time_set = False

          def handle_rst_msg(self, msg):
              reset_msg = pmt.to_python(msg)
              #print (reset_msg)

              if self.tx_time_set and reset_msg[1] and reset_msg[0] == 'reset':
                  self.tx_time_set = False
                  #print (self.tx_time_set)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              time = self.usrp.get_time_now()

              output_items[0][:] = input_items[0]
              self.call = self.call + 1

              #print (f"Call: {self.call}")

              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))

              if not self.tx_time_set:
                  self.tx_secs = int(time.get_real_secs())+self.delay
                  self.tx_fracs = time.get_real_secs() - int(time.get_real_secs())
                  self.tx_time_set = True
                  
                  for tag in tagTuple:
                      if pmt.to_python(tag.key) == "packet_len":
                          self.add_item_tag(0, tag.offset, pmt.intern('tx_time'), pmt.to_pmt((self.tx_secs, self.tx_fracs)))
                          self.add_item_tag(0, tag.offset, pmt.intern('tx_sob'), pmt.PMT_T)
                          #self.add_item_tag(0, 0, pmt.intern('packet_len'), tag.value)
                          self.packet_length = pmt.to_python(tag.value)
                          self.consumed_packets = 0
                          self.set_eob = True
                          
                          break

              if self.set_eob:
                  #print (self.consumed_packets, len(output_items[0]), self.sample_count + (self.packet_length - self.consumed_packets), self.packet_length)
                  if (self.consumed_packets + len(output_items[0])) >= self.packet_length:
                      self.add_item_tag(0, self.sample_count, pmt.intern('tx_eob'), pmt.PMT_T)
                      self.set_eob = False

                  self.consumed_packets = self.consumed_packets + len(output_items[0])

              pmt_msg = pmt.to_pmt(('tx_time', self.tx_secs+self.tx_fracs))
              self.message_port_pub(pmt.intern(self.tx_time_out ), pmt_msg)
              # if self.packet_length < self.consumed_packets and self.set_eob:
              #     self.add_item_tag(0, self.sample_count+self.packet_length, pmt.intern('tx_eob'), pmt.PMT_T)
              #     self.set_eob = False 3856 
              # else:
              #     self.consumed_packets = self.consumed_packets + len(output_items[0])

              # Add EOB at the end of buffer
                  
                  

             # print ("Key: " + pmt.to_python(tag.key) + " " + str(tag.offset) + " " + str(tag.value))

              # tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))

              # for tag in tagTuple:
              #     print ("Key: " + pmt.to_python(tag.key) + " " + str(tag.offset) + " " + str(tag.value))

              self.sample_count = self.sample_count + len(output_items[0])
              return len(output_items[0])
    delay: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: packet_tx_0
  id: packet_tx
  parameters:
    hdr_const: Const_HDR
    hdr_enc: enc_hdr
    hdr_format: hdr_format
    pad_end: pad_end
    pad_start: pad_start
    pld_const: Const_PLD
    pld_enc: enc
    psf_taps: tx_rrc_taps
    sps: sps
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      self.epy_block_1.usrp = self.uhd_usrp_sink_0
      self.uhd_usrp_sink_0.set_time_next_pps(uhd.time_spec(0.0))
    section: main_after_init
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq * 1e6
    dev_args: '"serial=31EABEA, underflow_policy=next_packet"'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:1234
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:1237
    timeout: '100'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', epy_block_1, '0']
- [epy_block_1, '0', uhd_usrp_sink_0, '0']
- [packet_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_pull_msg_source_0, out, packet_tx_0, in]
- [zeromq_pull_msg_source_0_0, out, epy_block_1, reset]

metadata:
  file_format: 1
  grc_version: gfe42f6a4a
